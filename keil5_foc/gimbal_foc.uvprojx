# Keil uVision project gimbal_foc.uvprojx, settings and files
target F103C8_FOC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: gimbal_foc +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\BSP;.\Control;.\Startup;.\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group SPL
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c
  group BSP
    ./BSP/: board.c as5600.c
  group Control
    ./Control/: foc_math.c motor.c encoder_tracking.c
  group User
    ./User/: main.c
