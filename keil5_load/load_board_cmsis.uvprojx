# Keil uVision project load_board_cmsis.uvprojx, settings and files
target LOAD_BOARD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(170000000) ELITTLE
  output: load_board +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G431xx,USE_HAL_DRIVER
  c include: .\User;..\keil5_host\User;..\keil5_host\BSP;..\keil5_g431\User;..\keil5_g431\BSP;..\keil5_g431\Libraries\CMSIS\Core;..\keil5_g431\Libraries\CMSIS\Device;..\keil5_g431\Libraries\HAL\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../keil5_g431/Startup/: startup_stm32g431xx.s system_stm32g4xx.c
  group HAL
    ../keil5_g431/Libraries/HAL/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_fdcan.c
  group Application
    ./User/: main.c
    ../keil5_host/BSP/: console.c esp_link.c icm42670.c can_host.c host_board.c
    ../keil5_g431/BSP/: clock.c
