# Keil uVision project gimbal_g431.uvprojx, settings and files
target G431CB_FOC (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(170000000) ELITTLE
  output: gimbal_g431 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32G431xx,USE_HAL_DRIVER
  c include: .\User;.\BSP;..\keil5_foc\Control;.\Libraries\CMSIS\Core;.\Libraries\CMSIS\Device;.\Libraries\HAL\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ./Startup/: startup_stm32g431xx.s system_stm32g4xx.c
  group HAL
    Libraries/HAL/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c
    ./Libraries/HAL/Src/: stm32g4xx_hal_fdcan.c
  group Application
    ./User/: main.c current_limit.c bench_current.c
    ./BSP/: clock.c board.c as5600.c can_transport.c can_commands.c current_sense.c
  group Shared verified F103 control
    ../keil5_foc/Control/: motor.c foc_math.c encoder_tracking.c trajectory.c
